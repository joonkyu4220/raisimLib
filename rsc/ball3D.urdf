Commit message: update ball urdf

File: rsc/ball3D.urdf (robot description, URDF)
Before this commit: robot ball2D, 3 links, 1 joints
Links:
- link ball: geometry collision sphere radius=0.11; visual sphere radius=0.11
